options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: test_top_block
    output_language: python
    title: Testing
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: 8e6
    step: 1e6
    stop: 20e6
    value: 20e6
  states: {}
- name: cuttoff
  id: variable_qtgui_range
  parameters:
    label: Cut Off
    start: '0'
    step: 5e3
    stop: 1500e3
    value: 1050e3
  states: {}
- name: factor
  id: variable
  parameters:
    value: 1/4
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: header_chosen_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: payload_chosen_constellation
  id: variable_constellation
  parameters:
    const_points: '[-7-7j, -5-7j, -3-7j, -1-7j, 1-7j, 3-7j, 5-7j, 7-7j, -7-5j, -5-5j, -3-5j, -1-5j, 1-5j, 3-5j, 5-5j, 7-5j, -7-3j, -5-3j, -3-3j, -1-3j, 1-3j, 3-3j, 5-3j, 7-3j, -7-1j, -5-1j, -3-1j, -1-1j, 1-1j, 3-1j, 5-1j, 7-1j, -7+1j, -5+1j, -3+1j, -1+1j, 1+1j, 3+1j, 5+1j, 7+1j, -7+3j, -5+3j, -3+3j, -1+3j, 1+3j, 3+3j, 5+3j, 7+3j, -7+5j, -5+5j, -3+5j, -1+5j, 1+5j, 3+5j, 5+5j, 7+5j, -7+7j, -5+7j, -3+7j, -1+7j, 1+7j, 3+7j, 5+7j, 7+7j]'
    precision: '8'
    sym_map: '[0, 8, 24, 16, 48, 56, 40, 32, 1, 9, 25, 17, 49, 57, 41, 33, 3, 11, 27, 19, 51, 59, 43, 35, 2, 10, 26, 18, 50, 58, 42, 34, 6, 14, 30, 22, 54, 62, 46, 38, 7, 15, 31, 23, 55, 63, 47, 39, 5, 13, 29, 21, 53, 61, 45, 37, 4, 12, 28, 20, 52, 60, 44, 36]'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable_qtgui_range
  parameters:
    label: Transition
    start: '0'
    step: 5e3
    stop: 1000e3
    value: 120e3
  states: {}
- name: transmit_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/confused/Downloads/output.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/confused/Downloads/sample3.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/50
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1, 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0)
  states: {state: disabled}
- name: build_packet_new_0
  id: build_packet_new
  parameters:
    divide: '1'
    header_constell: digital.constellation_bpsk()
    payload_constell: payload_chosen_constellation
    samp_rate: samp_rate
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1'
    freq_offset: '.025'
    noise_voltage: '0.2'
    seed: '0'
    taps: '1.0 '
  states: {state: disabled}
- name: deconstruct_packets_new_0
  id: deconstruct_packets_new
  parameters:
    header_mod: digital.constellation_bpsk()
    multiply: '1'
    payload_mod: payload_chosen_constellation
    samp_rate: samp_rate
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cuttoff
    decim: '1'
    gain: '1'
    samp_rate: transmit_rate
    type: ccc
    width: transition
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '47'
    gain: '1'
    ntaps: int(11*transmit_rate)
    samp_rate: transmit_rate
    sym_rate: '1.0'
    type: ccc
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0000000000000000f77c60dc235e53c3
    bb_gain0: '0'
    bw0: transmit_rate
    freq0: freq
    gain0: '14'
    if_gain0: '47'
    sample_rate: transmit_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000088869dc294cae1b
    bb_gain0: '0'
    bw0: transmit_rate
    freq0: freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '11'
    sample_rate: transmit_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: 'Receiver Freqency '
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: Transmit Frequency
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Output File
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Input File
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: Transmitter Time
    size: '1024'
    srate: transmit_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: Transmitter Pre-OFDM
    size: '1024'
    srate: transmit_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: Receiver Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(transmit_rate/samp_rate)
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(transmit_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    bandwidth: transmit_rate
    center_freq: freq
    dev_args: hackrf=0
    samp_rate: transmit_rate
    type: fc32
    vga: '40'
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    bandwidth: transmit_rate
    center_freq: freq
    dev_args: hackrf=1
    gain: '40'
    samp_rate: transmit_rate
    type: fc32
    vga: '10'
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', build_packet_new_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_file_source_0, '0', build_packet_new_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', deconstruct_packets_new_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_vector_source_x_0, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_0, '0', build_packet_new_0, '0']
- [build_packet_new_0, '0', blocks_multiply_const_vxx_0, '0']
- [build_packet_new_0, '0', filter_fft_rrc_filter_0, '0']
- [build_packet_new_0, '0', rational_resampler_xxx_0, '0']
- [build_packet_new_0, '2', qtgui_time_sink_x_0_1_0, '0']
- [channels_channel_model_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [deconstruct_packets_new_0, '0', blocks_char_to_float_1, '0']
- [deconstruct_packets_new_0, '0', blocks_file_sink_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_time_sink_x_0_2, '0']
- [filter_fft_low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_time_sink_x_0_1, '0']
- [filter_fft_rrc_filter_0, '0', soapy_hackrf_sink_0, '0']
- [osmosdr_source_0, '0', deconstruct_packets_new_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0_2, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', deconstruct_packets_new_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [soapy_hackrf_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
