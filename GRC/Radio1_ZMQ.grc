options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: rd1zmq
    output_language: python
    title: rd1zmq
  states: {}

blocks:
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 5.8e9
  states: {}
- name: osmosdr_source_0_1
  id: osmosdr_source
  parameters:
    args: hackrf=0000000000000000f77c60dc235e53c3
    bb_gain0: rxBB
    bw0: samp_rate
    freq0: freq
    gain0: '14'
    gain_mode0: 'True'
    if_gain0: rxIF
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: 'Receiver Freqency '
    type: complex
  states: {}
- name: rxBB
  id: parameter
  parameters:
    label: Receiver Baseband Gain
    type: intx
    value: '0'
  states: {}
- name: rxIF
  id: parameter
  parameters:
    label: Receiver IF Gain
    type: intx
    value: '40'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2e6
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8004'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:1234
    key: '""'
    timeout: '100'
    type: complex
  states: {}

connections:
- [osmosdr_source_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0_1, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
