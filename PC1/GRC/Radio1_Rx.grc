options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Rx
  states: {}

blocks:
- name: payload_chosen_constellation
  id: variable_constellation
  parameters:
    const_points: '[-7-7j, -5-7j, -3-7j, -1-7j, 1-7j, 3-7j, 5-7j, 7-7j, -7-5j, -5-5j, -3-5j, -1-5j, 1-5j, 3-5j, 5-5j, 7-5j, -7-3j, -5-3j, -3-3j, -1-3j, 1-3j, 3-3j, 5-3j, 7-3j, -7-1j, -5-1j, -3-1j, -1-1j, 1-1j, 3-1j, 5-1j, 7-1j, -7+1j, -5+1j, -3+1j, -1+1j, 1+1j, 3+1j, 5+1j, 7+1j, -7+3j, -5+3j, -3+3j, -1+3j, 1+3j, 3+3j, 5+3j, 7+3j, -7+5j, -5+5j, -3+5j, -1+5j, 1+5j, 3+5j, 5+5j, 7+5j, -7+7j, -5+7j, -3+7j, -1+7j, 1+7j, 3+7j, 5+7j, 7+7j]'
    precision: '8'
    sym_map: '[0, 8, 24, 16, 48, 56, 40, 32, 1, 9, 25, 17, 49, 57, 41, 33, 3, 11, 27, 19, 51, 59, 43, 35, 2, 10, 26, 18, 50, 58, 42, 34, 6, 14, 30, 22, 54, 62, 46, 38, 7, 15, 31, 23, 55, 63, 47, 39, 5, 13, 29, 21, 53, 61, 45, 37, 4, 12, 28, 20, 52, 60, 44, 36]'
    type: bpsk
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/ryan/New Volume/Senior Design/Working On/received.ddi
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: deconstruct_packets_new_0
  id: deconstruct_packets_new
  parameters:
    header_mod: digital.constellation_bpsk()
    multiply: '1'
    payload_mod: payload_chosen_constellation
    samp_rate: samp_rate
    thresh: rxThresh
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 920e6
  states: {}
- name: osmosdr_source_0_1_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: rxBB
    bw0: 2e6
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rxIF
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: 'Receiver Freqency '
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Received Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rxBB
  id: parameter
  parameters:
    label: Receiver Baseband Gain
    type: intx
    value: '0'
  states: {}
- name: rxIF
  id: parameter
  parameters:
    label: Receiver IF Gain
    type: intx
    value: '0'
  states: {}
- name: rxThresh
  id: parameter
  parameters:
    label: Receiver Baseband Gain
    value: '.915'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2e6
  states: {}
- name: xmlrpc_server_0_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8001'
  states: {}

connections:
- [blocks_copy_0, '0', deconstruct_packets_new_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0_2, '0']
- [deconstruct_packets_new_0, '0', blocks_file_sink_0, '0']
- [deconstruct_packets_new_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [osmosdr_source_0_1_0, '0', blocks_copy_0, '0']
- [osmosdr_source_0_1_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
