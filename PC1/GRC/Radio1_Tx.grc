options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Tx_R1
  states: {}

blocks:
- name: payload_chosen_constellation
  id: variable_constellation
  parameters:
    const_points: '[-7-7j, -5-7j, -3-7j, -1-7j, 1-7j, 3-7j, 5-7j, 7-7j, -7-5j, -5-5j, -3-5j, -1-5j, 1-5j, 3-5j, 5-5j, 7-5j, -7-3j, -5-3j, -3-3j, -1-3j, 1-3j, 3-3j, 5-3j, 7-3j, -7-1j, -5-1j, -3-1j, -1-1j, 1-1j, 3-1j, 5-1j, 7-1j, -7+1j, -5+1j, -3+1j, -1+1j, 1+1j, 3+1j, 5+1j, 7+1j, -7+3j, -5+3j, -3+3j, -1+3j, 1+3j, 3+3j, 5+3j, 7+3j, -7+5j, -5+5j, -3+5j, -1+5j, 1+5j, 3+5j, 5+5j, 7+5j, -7+7j, -5+7j, -3+7j, -1+7j, 1+7j, 3+7j, 5+7j, 7+7j]'
    precision: '8'
    sym_map: '[0, 8, 24, 16, 48, 56, 40, 32, 1, 9, 25, 17, 49, 57, 41, 33, 3, 11, 27, 19, 51, 59, 43, 35, 2, 10, 26, 18, 50, 58, 42, 34, 6, 14, 30, 22, 54, 62, 46, 38, 7, 15, 31, 23, 55, 63, 47, 39, 5, 13, 29, 21, 53, 61, 45, 37, 4, 12, 28, 20, 52, 60, 44, 36]'
    type: bpsk
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\racin\Downloads\17500-ma1.pdf
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: transmit_divider
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 1, 1)
  states: {}
- name: build_packet_new_0_0
  id: build_packet_new
  parameters:
    divide: '1'
    header_constell: digital.constellation_bpsk()
    payload_constell: payload_chosen_constellation
    samp_rate: samp_rate
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 922e6
  states: {}
- name: osmosdr_sink_0_1
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '0'
    bw0: samp_rate
    freq0: freq
    gain0: '14'
    if_gain0: '47'
    sample_rate: 8e6
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: 'Receiver Freqency '
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: Transmit Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: File Source Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(8e6)
    type: ccc
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2e6
  states: {}
- name: transmit_divider
  id: parameter
  parameters:
    label: Transmit Divider
    type: eng_float
    value: 1/50
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8000'
  states: {}

connections:
- [blocks_copy_0, '0', build_packet_new_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_copy_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_copy_0, '0']
- [blocks_vector_source_x_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [build_packet_new_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0_2, '0']

metadata:
  file_format: 1
