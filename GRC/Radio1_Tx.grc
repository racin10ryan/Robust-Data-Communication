options:
  parameters:
    author: ryan
    generate_options: qt_gui
    id: options_0
    output_language: python
    title: Tx_R1
  states: {}

blocks:
- name: payload_chosen_constellation
  id: variable_constellation
  parameters:
    const_points: '[-7-7j, -5-7j, -3-7j, -1-7j, 1-7j, 3-7j, 5-7j, 7-7j, -7-5j, -5-5j, -3-5j, -1-5j, 1-5j, 3-5j, 5-5j, 7-5j, -7-3j, -5-3j, -3-3j, -1-3j, 1-3j, 3-3j, 5-3j, 7-3j, -7-1j, -5-1j, -3-1j, -1-1j, 1-1j, 3-1j, 5-1j, 7-1j, -7+1j, -5+1j, -3+1j, -1+1j, 1+1j, 3+1j, 5+1j, 7+1j, -7+3j, -5+3j, -3+3j, -1+3j, 1+3j, 3+3j, 5+3j, 7+3j, -7+5j, -5+5j, -3+5j, -1+5j, 1+5j, 3+5j, 5+5j, 7+5j, -7+7j, -5+7j, -3+7j, -1+7j, 1+7j, 3+7j, 5+7j, 7+7j]'
    precision: '8'
    sym_map: '[0, 8, 24, 16, 48, 56, 40, 32, 1, 9, 25, 17, 49, 57, 41, 33, 3, 11, 27, 19, 51, 59, 43, 35, 2, 10, 26, 18, 50, 58, 42, 34, 6, 14, 30, 22, 54, 62, 46, 38, 7, 15, 31, 23, 55, 63, 47, 39, 5, 13, 29, 21, 53, 61, 45, 37, 4, 12, 28, 20, 52, 60, 44, 36]'
    type: bpsk
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/ryan/Documents/Tests/input.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: transmit_divider
    type: complex
  states: {}
- name: build_packet_new_0_0
  id: build_packet_new
  parameters:
    divide: '1'
    header_constell: digital.constellation_bpsk()
    payload_constell: payload_chosen_constellation
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              self.system = pmt.intern("system")
              self.portName = 'Done'
              self.message_port_register_in(self.system)
              self.message_port_register_out(pmt.intern(self.portName))
              self.selector = True
              
          def set_msg_handler(self, msg):
          	PMT_msg=pmt.pmt_t(msg)
          	self.system_handler(msg)
              
              
          def handle_msg(self, msg):
          	PMT_msg=pmt.intern("Done")
          	self.message_port_pub(pmt.intern(self.portName), PMT_msg)
          		

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] 
              #if input_items[0] == None:
              	#Print("Donedf")
              return len(output_items[0])
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 915e6
  states: {}
- name: osmosdr_sink_0_1
  id: osmosdr_sink
  parameters:
    args: hackrf=0000000000000000f77c60dc235e53c3
    bb_gain0: '0'
    bw0: samp_rate
    freq0: freq
    gain0: '14'
    if_gain0: '47'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: Transmit Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    name: File Source Time
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 2e6
  states: {}
- name: transmit_divider
  id: parameter
  parameters:
    label: Transmit Divider
    type: eng_float
    value: 1/10
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8000'
  states: {}

connections:
- [blocks_copy_0, '0', build_packet_new_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_copy_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', epy_block_0, '0']
- [build_packet_new_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0, '0', osmosdr_sink_0_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_2, '0']
- [epy_block_0, Done, blocks_message_debug_0, print]

metadata:
  file_format: 1
